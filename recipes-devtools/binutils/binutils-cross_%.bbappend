# The R5900 form of sqrt.s. See files/0001-MIPS-R5900-sqrt.s-reads-its-operand-from-ft.patch.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-MIPS-R5900-sqrt.s-reads-its-operand-from-ft.patch"
