# The configuration of the X server: recipes-graphics/xorg-xserver/xserver-xf86-config/ps2/xorg.conf
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
